# Keil uVision project SignalGenie.uvproj, settings and files
target SignalGenie (ARM-ADS)
  device: LPC2138 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: SignalGenie +hex
  c flags: Optim=1
  c define: ARM7_LPC21xx_KEIL_RVDS KEIL_THUMB_INTERWORK
  c include: FreeRTOS\Source\include;FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx;.
  asm include: FreeRTOS\Source\portable\RVDS
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Main
    ./: main.c Startup.s
  group AL
    ./AL/: taskCapture.c taskCapture.h taskGenerate.c taskGenerate.h taskPlot.c taskPlot.h taskTerminal.c taskTerminal.h
  group HAL
    ./HAL/: KS0108.c KS0108.h
  group MCAL
    ./MCAL/: ADC.c ADC.h DAC.c DAC.h GPIO.c GPIO.h UART.c UART.h
  group FreeRTOS
    ./FreeRTOS/Source/portable/RVDS/ARM7_LPC21xx/: port.c portASM.s
    ./FreeRTOS/Source/: list.c tasks.c queue.c
    ./: FreeRTOSConfig.h
    ./FreeRTOS/Source/portable/MemMang/: heap_2.c
